options:
  parameters:
    generate_options: qt_gui
    id: top_bñpck
    output_language: python
    title: top_block
  states: {}

blocks:
- name: samp_rate
  id: variable
  parameters:
    value: '32000'
  states: {}
- name: blocks_wavfile_source_0
  id: blocks_wavfile_source
  parameters:
    file: /home/pablo/Escritorio/Comunicaciones/WhatsApp-Audio-2020-06-05-at-4.36.21-PM.wav
    repeat: 'True'
  states: {}
- name: epy_block_0
  id: epy_block
  parameters:
    _source_code: |
      import numpy as np
      from gnuradio import gr
      class mean_meter (gr. sync_block ):
      	def __init__ ( self ) :
      		gr. sync_block . __init__ (self ,
      			name =" e_mean_meter_ff ",
      			in_sig =[ np. float32 ],
      			out_sig =[ np. float32 ])
      		# variables externas
      		self . contador = 0
      		self . acum =0
      	def work (self , input_items , output_items ):
      		# traduccion a algo que podemos manejar mejor
      		in0 = input_items [0]
      		out0 = output_items [0]
      		# Logica principal
      		self . contador += len ( in0 )
      		self . acum += np. sum ( in0 )
      		out0 [:] = self . acum / self . contador
      		return len ( output_items [0])
  states: {}
- name: qtgui_time_sink_x_0
  id: qtgui_time_sink_x
  parameters:
    size: '1024'
    srate: samp_rate
    type: float
  states: {}
- name: qtgui_time_sink_x_1
  id: qtgui_time_sink_x
  parameters:
    size: '1024'
    srate: samp_rate
    type: float
  states: {}

connections:
- [blocks_wavfile_source_0, '0', epy_block_0, '0']
- [blocks_wavfile_source_0, '0', qtgui_time_sink_x_0, '0']
- [epy_block_0, '0', qtgui_time_sink_x_1, '0']

metadata:
  file_format: 1
